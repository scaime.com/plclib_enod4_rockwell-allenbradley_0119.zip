(* Logix 5000 DataType export TeNod4TCYCOUT; software revision 28.00 *)

TYPE TeNod4TCYCOUT :
STRUCT
   Command : INT;
END_STRUCT
END_TYPE
